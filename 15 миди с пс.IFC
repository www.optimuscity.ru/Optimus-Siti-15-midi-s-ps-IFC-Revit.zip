Properties of the parts of a building model (IFC4), part 3 of 3

# IfcBuildingElementProxy: 15 миди.stp[760]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[761]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[762]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[763]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[764]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[765]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[766]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[767]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[768]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[769]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[76]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[770]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[771]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[772]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[773]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[774]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[775]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[776]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[777]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[778]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[779]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[77]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[780]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[781]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[782]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[783]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[784]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[785]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[786]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[787]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[788]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[789]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[78]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[790]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[791]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[792]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[793]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[794]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[795]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[796]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[797]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[798]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[799]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[79]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[7]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[800]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[801]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[802]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[803]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[804]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[805]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[806]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[807]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[808]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[809]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[80]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[810]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[811]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[812]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[813]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[814]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[815]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[816]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[817]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[818]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[819]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[81]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[820]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[821]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[822]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[823]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[824]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[825]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[826]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[827]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[828]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[829]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[82]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[830]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[831]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[832]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[833]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[834]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[835]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[836]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[837]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[838]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[839]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[83]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[840]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[841]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[842]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[843]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[844]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[845]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[846]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[847]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[848]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[849]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[84]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[850]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[851]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[852]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[853]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[854]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[855]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[856]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[857]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[858]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[859]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[85]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[860]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[861]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[862]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[863]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[864]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[865]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[866]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[867]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[868]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[869]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[86]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[870]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[871]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[872]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[873]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[874]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[875]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[876]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[877]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[878]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[879]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[87]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[880]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[881]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[882]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[883]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[884]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[885]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[886]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[887]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[888]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[889]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[88]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[890]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[891]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[892]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[893]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[894]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[895]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[896]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[897]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[898]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[899]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[89]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[8]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[900]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[901]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[902]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[903]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[904]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[905]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[906]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[907]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[908]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[909]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[90]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[910]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[911]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[912]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[913]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[914]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[915]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[916]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[917]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[918]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[919]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[91]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[920]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[921]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[922]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[923]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[924]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[925]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[926]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[927]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[928]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[929]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[92]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[930]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[931]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[932]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[933]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[934]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[935]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[936]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[937]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[938]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[939]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[93]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[940]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[941]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[942]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[943]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[944]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[945]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[946]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[947]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[948]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[949]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[94]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[950]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[951]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[952]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[953]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[954]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[955]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[956]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[957]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[958]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[959]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[95]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[960]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[961]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[962]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[963]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[964]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[965]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[966]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[967]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[968]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[969]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[96]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[970]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[971]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[972]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[973]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[974]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[975]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[976]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[977]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[978]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[979]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[97]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[980]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[981]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[982]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[983]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[984]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[985]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[986]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[987]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[988]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[989]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[98]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[990]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[991]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[992]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[993]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[994]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[995]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[996]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[997]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[998]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[999]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[99]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[9]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: SS.SEMA.2400 - Сима-профиль (66)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: SS.SEMA.2400 - Сима-профиль — обрезан 1600 (22)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

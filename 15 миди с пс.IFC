Properties of the parts of a building model (IFC4), part 1 of 3

# File
Description: IFC4
File name: 15 миди с пс.IFC
Time: 2025-11-26T10:49:15
Written by: SwIFC
Made in: SolidWorks 2020

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: 15 миди.stp[1000]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1001]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1002]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1003]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1004]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1005]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1006]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1007]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1008]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1009]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[100]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1010]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1011]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1012]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1013]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1014]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1015]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1016]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1017]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1018]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1019]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[101]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1020]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1021]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1022]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1023]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1024]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1025]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1026]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1027]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1028]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1029]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[102]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1030]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1031]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1032]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1033]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1034]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1035]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1036]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1037]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1038]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1039]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[103]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1040]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1041]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1042]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1043]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1044]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1045]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1046]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1047]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1048]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1049]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[104]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1050]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1051]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1052]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1053]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1054]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1055]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1056]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1057]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1058]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1059]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[105]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1060]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1061]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1062]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1063]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1064]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1065]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1066]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1067]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1068]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1069]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[106]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1070]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1071]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1072]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1073]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1074]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1075]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1076]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1077]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1078]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1079]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[107]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1080]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1081]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1082]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1083]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1084]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1085]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1086]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1087]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1088]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1089]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[108]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1090]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1091]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1092]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1093]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1094]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1095]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1096]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1097]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1098]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1099]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[109]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[10]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1100]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1101]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1102]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1103]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1104]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1105]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1106]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1107]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1108]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1109]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[110]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1110]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1111]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1112]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1113]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1114]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1115]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1116]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1117]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1118]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1119]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[111]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1120]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1121]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1122]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1123]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1124]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1125]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1126]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1127]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1128]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1129]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[112]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1130]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1131]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1132]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1133]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1134]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1135]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1136]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1137]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1138]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1139]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[113]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1140]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1141]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1142]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1143]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1144]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1145]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1146]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1147]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1148]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1149]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[114]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1150]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1151]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1152]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1153]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1154]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1155]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1156]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1157]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1158]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1159]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[115]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1160]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1161]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1162]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1163]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1164]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1165]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1166]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1167]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1168]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1169]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[116]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1170]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1171]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1172]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1173]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1174]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1175]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1176]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1177]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1178]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1179]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[117]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1180]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1181]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1182]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1183]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1184]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1185]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1186]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1187]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1188]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1189]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[118]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1190]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1191]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1192]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1193]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1194]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1195]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1196]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1197]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1198]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1199]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[119]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[11]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1200]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1201]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1202]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1203]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1204]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1205]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1206]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1207]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1208]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1209]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[120]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1210]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1211]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1212]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1213]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1214]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1215]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1216]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1217]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1218]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1219]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[121]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1220]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1221]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1222]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1223]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1224]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1225]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1226]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1227]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1228]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1229]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[122]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1230]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1231]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1232]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1233]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1234]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1235]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1236]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1237]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1238]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1239]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[123]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1240]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1241]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1242]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1243]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1244]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1245]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1246]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1247]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1248]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1249]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[124]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1250]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1251]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1252]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1253]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1254]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1255]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1256]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1257]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1258]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1259]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[125]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1260]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1261]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1262]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1263]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1264]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1265]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1266]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1267]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1268]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1269]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[126]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1270]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1271]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1272]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1273]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1274]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1275]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1276]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1277]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1278]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1279]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[127]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1280]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1281]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1282]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1283]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1284]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1285]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1286]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1287]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1288]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1289]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[128]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1290]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1291]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1292]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1293]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1294]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1295]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1296]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1297]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1298]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1299]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[129]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[12]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1300]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1301]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1302]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1303]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1304]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1305]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1306]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1307]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1308]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1309]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[130]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1310]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1311]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1312]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1313]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1314]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1315]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1316]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1317]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1318]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1319]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[131]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1320]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1321]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1322]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1323]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1324]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1325]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1326]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1327]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1328]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1329]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[132]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1330]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1331]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1332]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1333]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1334]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1335]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1336]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1337]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1338]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1339]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[133]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1340]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1341]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1342]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1343]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1344]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1345]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1346]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1347]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1348]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1349]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[134]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1350]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1351]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1352]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1353]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1354]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1355]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1356]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1357]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1358]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1359]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[135]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1360]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1361]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1362]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1363]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1364]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1365]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1366]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1367]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1368]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1369]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[136]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1370]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1371]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1372]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1373]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1374]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1375]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1376]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1377]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1378]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1379]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[137]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1380]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1381]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1382]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1383]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1384]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1385]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1386]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1387]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1388]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1389]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[138]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1390]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1391]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1392]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1393]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1394]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1395]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1396]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1397]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1398]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1399]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[139]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[13]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1400]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1401]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1402]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1403]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1404]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1405]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1406]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1407]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1408]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1409]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[140]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1410]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1411]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1412]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1413]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1414]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1415]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1416]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1417]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1418]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1419]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[141]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1420]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1421]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1422]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1423]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1424]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1425]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1426]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1427]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1428]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1429]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[142]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1430]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1431]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1432]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1433]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1434]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1435]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1436]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1437]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1438]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1439]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[143]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1440]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1441]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1442]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1443]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1444]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1445]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1446]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1447]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1448]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1449]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[144]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1450]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1451]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1452]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1453]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1454]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1455]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1456]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1457]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1458]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1459]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[145]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1460]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1461]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1462]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1463]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1464]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1465]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1466]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1467]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1468]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1469]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[146]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1470]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1471]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1472]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1473]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1474]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1475]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1476]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1477]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1478]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1479]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[147]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1480]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1481]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1482]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1483]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1484]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1485]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1486]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1487]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1488]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1489]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[148]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1490]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1491]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1492]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1493]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1494]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1495]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1496]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1497]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1498]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1499]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[149]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[14]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1500]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1501]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1502]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1503]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1504]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1505]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1506]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1507]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1508]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1509]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[150]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1510]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1511]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1512]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1513]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1514]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1515]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1516]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1517]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1518]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1519]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[151]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1520]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1521]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1522]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1523]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1524]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1525]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1526]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1527]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1528]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1529]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[152]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1530]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1531]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1532]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1533]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1534]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1535]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1536]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1537]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1538]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1539]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[153]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1540]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1541]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1542]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1543]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1544]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1545]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1546]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1547]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1548]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1549]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[154]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1550]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1551]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1552]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1553]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1554]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1555]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1556]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1557]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1558]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1559]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[155]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1560]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1561]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1562]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1563]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1564]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1565]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1566]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1567]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1568]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1569]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[156]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1570]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1571]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1572]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1573]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1574]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1575]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1576]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1577]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1578]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1579]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[157]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1580]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1581]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1582]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1583]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1584]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1585]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1586]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1587]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1588]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1589]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[158]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1590]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1591]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1592]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1593]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1594]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1595]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1596]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1597]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1598]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1599]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[159]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[15]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1600]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1601]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1602]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1603]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1604]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 15 миди.stp[1605]
In: Default Storey
